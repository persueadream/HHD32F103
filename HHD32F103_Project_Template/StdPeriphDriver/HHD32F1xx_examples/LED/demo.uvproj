# Keil uVision project demo.uvproj, settings and files
target Run In Flash (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: demo +hex
  c flags: Optim=1
  c define: __CC_ARM __UART0
  c include: .\myapp\inc;..\..\HHD32F1xx_library\Drivers\include;..\..\HHD32F1xx_library\Core\CM3\DeviceSupport\HHD32F1xx;..\..\HHD32F1xx_library\Core\CM3\CoreSupport
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ../../HHD32F1xx_library/Core/CM3/CoreSupport/: core_cm3.c
    ../../HHD32F1xx_library/Core/CM3/DeviceSupport/HHD32F1xx/: system_HHD32F1xx.c
    ../../HHD32F1xx_library/Core/CM3/DeviceSupport/HHD32F1xx/Startup/rvds/: startup_HHD32F1xx_s.s
    ../../HHD32F1xx_library/Drivers/source/: hhd_sys.c hhd_gpio.c
  group App
    ./myapp/src/: main.c
target Run In RAM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: demo
  c flags: Optim=1
  c define: __UART0
  c include: ..\common\Drivers\include;..\common\Core\CM0\DeviceSupport\XN11E
  memory RVCT4: ROM 0x10000000 size 0x1000
  memory RVCT9: RAM 0x10001000 size 0x1000
