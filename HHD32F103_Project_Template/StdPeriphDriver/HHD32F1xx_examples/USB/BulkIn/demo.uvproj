# Keil uVision project demo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: demo
  c flags: Optim=1
  c define: CORTEX_M3
  c include: ..\..\..\HHD32F1xx_library\Drivers\include;..\..\HHD32F1xx_library\Core\CM3\DeviceSupport\HHD32F1xx;..\..\HHD32F1xx_library\Core\CM3\CoreSupport;..\..\..\HHD32F1xx_library\Drivers\include\usb;..\..\..\HHD32F1xx_library\Core\CM3\DeviceSupport\HHD32F1xx
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ../../../HHD32F1xx_library/Drivers/source/usb/: desc.c endpoint.c endpoint0.c fifo.c musbfsfc.c reset.c
  group common
    ../../../HHD32F1xx_library/Core/CM3/CoreSupport/: core_cm3.c
    ../../../HHD32F1xx_library/Core/CM3/DeviceSupport/HHD32F1xx/: system_HHD32F1xx.c
    ../../../HHD32F1xx_library/Core/CM3/DeviceSupport/HHD32F1xx/Startup/rvds/: startup_HHD32F1xx_s.s
    ../../../HHD32F1xx_library/Drivers/source/: hhd_sys.c
    ./src/: main.c
