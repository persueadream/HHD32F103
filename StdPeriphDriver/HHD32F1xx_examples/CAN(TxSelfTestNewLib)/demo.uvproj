# Keil uVision project demo.uvproj, settings and files
target Run In Flash (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: demo
  c flags: Optim=1
  c include: .\myapp\inc;..\..\HHD32F1xx_library\Drivers\include;..\..\HHD32F1xx_library\Core\CM3\DeviceSupport\HHD32F1xx;..\..\HHD32F1xx_library\Core\CM3\CoreSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ../../HHD32F1xx_library/Core/CM3/CoreSupport/: core_cm3.c
    ../../HHD32F1xx_library/Core/CM3/DeviceSupport/HHD32F1xx/: system_HHD32F1xx.c
    ../../HHD32F1xx_library/Core/CM3/DeviceSupport/HHD32F1xx/Startup/rvds/: startup_HHD32F1xx_s.s
    ../../HHD32F1xx_library/Drivers/source/: hhd_sys.c hhd_can.c hhd_uart.c
    ./myapp/src/: USART_user.c system_user.c
  group App
    ./myapp/src/: main.c
target Run In RAM (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: demo
  c flags: Optim=1
  c include: .\myapp\inc;..\..\G32F1xx_library\Drivers\include;..\..\G32F1xx_library\Core\CM3\DeviceSupport\G32F1xx;..\..\G32F1xx_library\Core\CM3\CoreSupport
  memory RVCT4: ROM 0x20000000 size 0x1000
  memory RVCT9: RAM 0x20001000 size 0x1000
