# Keil uVision project project.uvproj, settings and files
target HHD32F103_RBT6 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: project
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe Project.axf --bin -o Project.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,I2C_SLAVER,I2C_MASTER
  c include: ..\StdPeriphDriver\HHD32F1xx_library\Core\CM3\CoreSupport;..\StdPeriphDriver\HHD32F1xx_library\Core\CM3\DeviceSupport\HHD32F1xx;..\StdPeriphDriver\HHD32F1xx_library\Drivers\include;..\Hardware;..\System;..\User;..\Debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../User/: main.c hhd32f10x_it.c
  group Debug
    ../Debug/: Debug.c
  group System
    ../System/: delay.c system.c
  group Hardware
    ../Hardware/: hal.c adc.c gpio.c i2c.c spi.c timer.c uart.c can.c pwm.c flash.c
  group StdPeriphDriver
    ../StdPeriphDriver/HHD32F1xx_library/Drivers/source/: hhd_adc.c hhd_can.c hhd_crc.c hhd_dac.c hhd_dma.c hhd_gpio.c hhd_iap.c hhd_iic.c hhd_pwm.c hhd_rtc.c hhd_spi.c hhd_sys.c hhd_timer.c hhd_uart.c hhd_wdt.c
  group CMSIS
    ../StdPeriphDriver/HHD32F1xx_library/Core/CM3/CoreSupport/: core_cm3.c
    ../StdPeriphDriver/HHD32F1xx_library/Core/CM3/DeviceSupport/HHD32F1xx/: system_HHD32F1xx.c
  group Startup
    ../StdPeriphDriver/HHD32F1xx_library/Core/CM3/DeviceSupport/HHD32F1xx/Startup/rvds/: startup_HHD32F1xx_s.s
  group Log
    ../Log/: LogMsg.txt
